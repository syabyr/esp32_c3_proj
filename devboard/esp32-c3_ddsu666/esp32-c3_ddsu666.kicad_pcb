# Repository syabyr/esp32_c3_proj

## KiCad design devboard/esp32-c3_ddsu666/esp32-c3_ddsu666.kicad_pcb

Parts:
C1, C2, C6, C10, C11: 0.1uF; C_0402_1005Metric
C3: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 10uF; C_1812_4532Metric
C8: 10uF; C_0805_2012Metric
C12: 100n; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1, D2: LED; LED_0805_2012Metric
J1, J3, J4, J5: Conn_01x01; PinHeader_1x01_P2.00mm_Vertical
J2: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
R1, R2: 4.7k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R11, R12, R13, R14: 10K; R_0402_1005Metric
U1: ESP32-C3-MINI-1; ESP32-C3-MINI
U2: MAX13487EESA; SOIC-8_3.9x4.9mm_P1.27mm
U4: AP1117-33; SOT-223-3_TabPin2

Connections:
+3V3: C1.1, C2.1, C7.1, C8.1, C10.1, D1.2 (A), R11.1, R13.2, U1.3, U4.2 (VO)
+5V: C6.1, C12.2, J1.1, R2.2, U2.2 (RE#), U2.3 (SHDN#), U2.8 (VCC), U4.3 (VI)
/CHIP_PU: C11.1, R11.2, U1.8
/GPIO8: R13.1, U1.22
/GPIO9: C3.1, U1.23
A: J4.1, R2.1, U2.6 (A)
B: J5.1, R1.2, U2.7 (B)
GND: C1.2, C2.2, C3.2, C6.2, C7.2, C8.2, C10.2, C11.2, C12.1, J2.1, J3.1, R1.1, R12.2, R14.1, U1.1, U1.2, U1.11, U1.14, U1.36, U1.37, U1.38, U1.39, U1.40, U1.41, U1.42, U1.43, U1.44, U1.45, U1.46, U1.47, U1.48, U1.49, U1.50, U1.51, U1.52, U2.5 (GND), U4.1 (GND)
GPIO4: D2.2 (A), U1.18
unnamed: D1.1 (K), R12.1
unnamed: D2.1 (K), R14.2
U0RXD: J2.2, U1.30, U2.1 (RO)
U0TXD: J2.3, U1.31, U2.4 (DI)

Board: 4 copper layers, 30.0 x 25.0 mm, 25 parts (0 on the bottom side), 13 nets.

## KiCad design devboard/esp32-c1_devboard.rev2/esp32-c1_devboard.kicad_pcb

Board: 4 copper layers, 50.0 x 50.0 mm, 41 parts (2 on the bottom side), 33 nets.

Parts:
BOOT: SW_SPST; turtlekey
C1, C2, C3, C4, C6, C10: 0.1uF; C_0402_1005Metric
C5, C7: 10uF; C_1812_4532Metric
C8, C9: 10uF; C_0805_2012Metric
C11: 1uF; C_0402_1005Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380
IO4: LED; LED_0805_2012Metric
J1: USB_C
J2, J3: Conn_02x10_Odd_Even; PinHeader_2x10_P2.54mm_Vertical
Q1, Q2: S8050; SOT-23
R1, R2: 5K; R_0402_1005Metric
R3, R6, R7, R8: 0; R_0402_1005Metric
R4, R5: NC; R_0402_1005Metric
R9, R10, R11, R12, R13, R14: 10K; R_0402_1005Metric
RESET: SW_SPST; turtlekey
U1: ESP32-C3-MINI-1; ESP32-C3-MINI
U2: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U4: AP1117-33; SOT-223-3_TabPin2
VCC: LED; LED_0805_2012Metric

Connections:
+3V3: C1.1, C2.1, C7.1, C8.1, C9.1, C10.1, J2.1, J2.3, J2.5, J2.6, J2.7, J2.8, J3.3, J3.4, R11.1, R13.2, U1.3, U2.4, U2.16, U4.2, VCC.2
+5V: C5.1, C6.1, J1.A4, J1.A9, J1.B4, J1.B9, J2.2, U4.3
/DM: R3.2, U2.6
/DP: R6.2, U2.5
/DTR: Q2.1, R9.1, U2.13
/RTS: Q1.1, R10.1, U2.14
CHIP_PU: C4.1, C11.1, J3.10, Q1.3, R11.2, RESET.1, U1.8
GND: BOOT.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.A1, J1.A12, J1.B1, J1.B12, J1.S1, J2.4, J2.13, J2.15, J2.16, J2.17, J2.18, J2.19, J2.20, J3.1, J3.2, J3.15, J3.17, J3.18, J3.19, J3.20, R1.2, R2.2, R12.2, R14.1, RESET.2, U1.1, U1.2, U1.11, U1.14, U1.36, U1.37, U1.38, U1.39, U1.40, U1.41, U1.42, U1.43, U1.44, U1.45, U1.46, U1.47, U1.48, U1.49, U1.50, U1.51, U1.52, U2.1, U4.1
GPIO0: J2.11, U1.12
GPIO1: J2.12, U1.13
GPIO2: J2.9, U1.5
GPIO3: J2.10, U1.6
GPIO4: IO4.2, J3.16, U1.18
GPIO5: J3.13, U1.19
GPIO6: J3.14, U1.20
GPIO7: J3.11, U1.21
GPIO8: J3.12, R13.1, U1.22
GPIO9: BOOT.1, C3.1, J3.9, Q2.3, U1.23
GPIO10: J2.14, U1.16
GPIO18: J3.7, R4.2, U1.26
GPIO19: J3.8, R5.2, U1.27
unnamed: R12.1, VCC.1
unnamed: IO4.1, R14.2
unnamed: J1.A5, R1.1
unnamed: J1.A6, J1.B6, R5.1, R6.1
unnamed: J1.A7, J1.B7, R3.1, R4.1
unnamed: J1.B5, R2.1
unnamed: Q1.2, R9.2
unnamed: Q2.2, R10.2
unnamed: R7.1, U2.2
unnamed: R8.1, U2.3
U0RXD: J3.5, R7.2, U1.30
U0TXD: J3.6, R8.2, U1.31

## KiCad design devboard/esp32-c1_devboard/esp32-c1_devboard.kicad_pcb

Parts:
C1, C2, C3, C4, C6, C10: 0.1uF; C_0402_1005Metric
C5, C7, C8, C9: 10uF; C_0805_2012Metric
C11: 1uF; C_0402_1005Metric
D1: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D2: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
J1: USB_C
J2, J3: Conn_01x15; PinHeader_1x15_P2.54mm_Vertical
L1: NC; L_1008_2520Metric
Q1, Q2: S8050; SOT-23
R1, R2: 5K; R_0402_1005Metric
R3, R6, R7, R8, R12: 0; R_0402_1005Metric
R4, R5: NC; R_0402_1005Metric
R9, R10, R11, R13: 10K; R_0402_1005Metric
SW1, SW2: SW_SPST; SW_SPST_PTS810
U1: ESP32-C3-MINI-1; ESP32-C3-MINI
U2: CH340C; SOIC-16_3.9x9.9mm_P1.27mm
U3: NC; TSOT-23-5
U4: AP1117-33; SOT-223-3_TabPin2

Connections:
+3V3: C1.1, C2.1, C7.1, C8.1, C9.1, C10.1, D1.1 (VDD), D2.4 (VDD), J2.2, J2.3, L1.2, R11.1, R13.2, U1.3 (3V3), U2.4 (V3), U2.16 (VCC), U3.4 (FB), U4.2 (VO)
+5V: C5.1, C6.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J2.13, J2.14, U3.1 (Vin), U3.3 (EN), U4.3 (VI)
/CHIP_PU: C4.1, C11.1, J2.7, Q1.3 (C), R11.2, SW2.1 (A), U1.8 (EN)
/DM: R3.2, U2.6 (UD-)
/DP: R6.2, U2.5 (UD+)
/DTR: Q2.1 (E), R9.1, U2.13 (~DTR)
/GPIO0: J2.9, U1.12 (IO0)
/GPIO1: J2.10, U1.13 (IO1)
/GPIO2: J2.4, U1.5 (IO2)
/GPIO3: J2.5, U1.6 (IO3)
/GPIO4: J3.11, U1.18 (IO4)
/GPIO5: J3.10, U1.19 (IO5)
/GPIO6: J3.9, U1.20 (IO6)
/GPIO7: J3.8, U1.21 (IO7)
/GPIO8: J3.6, R12.1, R13.1, U1.22 (IO8)
/GPIO9: C3.1, J3.5, Q2.3 (C), SW1.1 (A), U1.23 (IO9)
/GPIO10: J2.11, U1.16 (IO10)
/GPIO18: J3.13, R4.2, U1.26 (IO18)
/GPIO19: J3.14, R5.2, U1.27 (IO19)
/RTS: Q1.1 (E), R10.1, U2.14 (~RTS)
/U0RXD: J3.3, R7.2, U1.30 (RXD0)
/U0TXD: J3.2, R8.2, U1.31 (TXD0)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, D1.3 (VSS), D2.2 (VSS), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J2.6, J2.8, J2.12, J2.15, J3.1, J3.4, J3.7, J3.12, J3.15, R1.2, R2.2, SW1.2 (B), SW2.2 (B), U1.1 (GND), U1.2 (GND), U1.11 (GND), U1.14 (GND), U1.36 (GND), U1.37 (GND), U1.38 (GND), U1.39 (GND), U1.40 (GND), U1.41 (GND), U1.42 (GND), U1.43 (GND), U1.44 (GND), U1.45 (GND), U1.46 (GND), U1.47 (GND), U1.48 (GND), U1.49 (GND), U1.50 (GND), U1.51 (GND), U1.52 (GND), U2.1 (GND), U3.2 (GND), U4.1 (GND)
unnamed: D1.2 (DOUT), D2.1 (DOUT)
unnamed: D1.4 (DIN), D2.3 (DIN), R12.2
unnamed: J1.A5 (CC1), R1.1
unnamed: J1.A6 (D+), J1.B6 (D+), R5.1, R6.1
unnamed: J1.A7 (D-), J1.B7 (D-), R3.1, R4.1
unnamed: J1.B5 (CC2), R2.1
unnamed: L1.1, U3.5 (SW)
unnamed: Q1.2 (B), R9.2
unnamed: Q2.2 (B), R10.2
unnamed: R7.1, U2.2 (TXD)
unnamed: R8.1, U2.3 (RXD)

Board: 2 copper layers, 29.2 x 45.0 mm, 38 parts (0 on the bottom side), 34 nets.

## Commit log

2021-12-21 rev1
2021-12-26 rev2
2021-12-26 hello world
2021-12-26 openocd
2022-01-09 blink
2022-02-12 ddsu666
